# Keil uVision project State_machine.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC834 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: State_machine
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd_comm.c intx_t.h lab2_board.h lcd_comm.h aduc834.c
